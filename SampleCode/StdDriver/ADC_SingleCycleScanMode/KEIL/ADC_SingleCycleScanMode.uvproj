# Keil uVision project ADC_SingleCycleScanMode.uvproj, settings and files
target ADC_SingleCycleScanMode (ARM-ADS)
  device: NUC029LAN Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: ADC_SingleCycleScanMode
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: ..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\NUC029xAN\Include;..\..\..\..\Library\CMSIS\Include
  library: MicroLIB
  link misc: --map --first='startup_NUC029xAN.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xAN/Source/: system_NUC029xAN.c
    ../../../../Library/Device/Nuvoton/NUC029xAN/Source/ARM/: startup_NUC029xAN.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: uart.c retarget.c clk.c sys.c adc.c
