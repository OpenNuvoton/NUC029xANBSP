# Keil uVision project fmc_ld_iap.uvproj, settings and files
target LDROM_code (ARM-ADS)
  device: NUC029LAN Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: LDROM_code
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC029xAN\Include;..\..\..\..\Library\CMSIS\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  link misc: --map --first='startup_NUC029xAN.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xAN/Source/: system_NUC029xAN.c
    ../../../../Library/Device/Nuvoton/NUC029xAN/Source/ARM/: startup_NUC029xAN.s
  group User
    ../: LDROM_main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c fmc.c clk.c
