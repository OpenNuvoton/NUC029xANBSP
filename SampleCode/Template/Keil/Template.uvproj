# Keil uVision project Template.uvproj, settings and files
target Template (6160000::V6.16::ARMCLANG)
  device: NUC029LAN Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: template
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\NUC029xAN\Include;..\..\..\Library\StdDriver\inc
  library: MicroLIB
  link misc: --map --first='startup_NUC029xAN.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC029xAN/Source/ARM/: startup_NUC029xAN.s
    ../../../Library/Device/Nuvoton/NUC029xAN/Source/: system_NUC029xAN.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c
  group User
    ../: main.c
